# Keil uVision project int_tutorial.uvprojx, settings and files
target IntApp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: int_tutorial
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  group src
    ./: main.c akcelerometr.c akcelerometr.h I2C.c I2C.h tpm.c tpm.h
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
